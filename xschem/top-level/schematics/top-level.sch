v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/2026/tt_sky26b_ldo_andriansyah/xschem/ldo_andriansyah/schematics/ldo-top.sym} 410 -460 0 0 {name=x1}
